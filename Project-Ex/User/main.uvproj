# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 wLevel=2
  c define: HSE_VALUE=8000000,USE_STDPERIPH_DRIVER
  c include: ..\StdLib\src;..\StdLib\inc;..\CMSIS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../CMSIS/Source/Templates/arm/: startup_stm32f40xx.s
  group User
    ./: main.c
  group CMSIS
    ../CMSIS/Source/Templates/: system_stm32f4xx.c
    ../StdLib/inc/: stm32f4xx_exti.h stm32f4xx_syscfg.h
    ../StdLib/src/: stm32f4xx_exti.c stm32f4xx_syscfg.c
  group StdLib
    ../StdLib/: stm32f4xx_conf.h
    ../StdLib/src/: misc.c stm32f4xx_delay.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_it.c utils.c stm32f4xx_usart.c Encoder.c PWM.c cambiengoc.c Timer.c Kalman.c Calib.c Uart.c PIDControl.c
    ../StdLib/inc/: stm32f4xx.h system_stm32f4xx.h stm32f4xx_i2c.h stm32f4xx_tim.h stm32f4xx_it.h include.h utils.h Define.h cambiengoc.h stm32f4xx_usart.h Calib.h Kalman.h Uart.h stdint.h PWM.h Encoder.h Timer.h PIDControl.h misc.h
